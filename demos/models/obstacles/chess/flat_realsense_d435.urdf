Commit message: corrected camera pose

File: demos/models/obstacles/chess/flat_realsense_d435.urdf (robot description, URDF)
Before this commit: robot flat_realsense, 1 links, 0 joints
Links:
- link base: geometry collision box size=0.10 0.025 0.025; collision box size=0.15 0.15 0.008
